PACKAGECONFIG:append = " eglfs"
